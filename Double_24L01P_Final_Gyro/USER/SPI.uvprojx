# Keil uVision project SPI.uvprojx, settings and files
target SPI (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FWLIB\inc;..\HARDWARE\IIC;..\HARDWARE\FSMC;..\HARDWARE\MPU6050;..\HARDWARE\USART
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c NRF24L01.c robot.c packet.c Comm.c Task.c timer.c exti.c Init.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/MPU6050/: mpu6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/FSMC/: fsmc.c
  group SYSTEM
    ../HARDWARE/USART/: bsp_debug_usart.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c
